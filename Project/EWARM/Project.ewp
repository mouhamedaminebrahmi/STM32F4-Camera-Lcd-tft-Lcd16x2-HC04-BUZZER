# IAR project Project.ewp, settings and files
configuration STM32F407VGT6 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4xx
  ICCARM.CCIncludePath2: ..; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\CMSIS\ST\STM32F4xx\Include; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group EWARM
    ../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: AsciiLib.c LCD.c misc.c pictures.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c
    ../../: dcmi_OV7670.c SCCB.C
    ../../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_exti.c
  group User
    ../: main.c
    ../../../Lcd16x2+HC04+BUZZER/: stm32f4xx_it.c
